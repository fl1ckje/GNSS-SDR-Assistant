options:
  parameters:
    generate_options: qt_gui
    id: spectrum_viewer
    output_language: python
    title: Spectrum viewer
  states: {}

blocks:
- name: amp
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 11,3,1,1
    label: AMP
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option0: '0'
    option1: '14'
    type: int
    value: '0'
  states: {}
- name: baseband_filter_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,3
    label: Baseband filter bandwidth, Hz
    start: '1750000'
    step: '250000'
    stop: '20000000'
    value: '10000000'
  states: {}
- name: carrier_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 9,4,4,1
    label: Center frequency
    labels: '["GLONASS L1 C/A - 1602.000 MHz", "GPS L1 C/A and Galileo E1b/c - 1575.420 MHz", "BeiDou B1I - 1561.098 MHz", "Galileo E6B - 1278.750 MHz", "BeiDou B3I - 1268.520 MHz", "GLONASS L2 C/A - 1246.000 MHz", "GPS L2C - 1227.600 MHz", "Galileo E5b - 1207.140 MHz", "GPS L5 and Galileo E5a - 1176.450 MHz"]'
    num_opts: '0'
    options: '[1602000000 , 1575420000, 1561098000, 1278750000, 1268520000, 1246000000, 1227000000, 1207140000, 1176450000]'
    type: int
    value: '1602000000'
    widget: radio_buttons
  states: {}
- name: lna
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,3,1,1
    label: LNA gain, dB
    start: '0'
    step: '8'
    stop: '40'
    value: '40'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,3
    label: Sample rate, Hz
    start: '8000000'
    step: '1000000'
    stop: '20000000'
    value: '8000000'
  states: {}
- name: vga
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,3,1,1
    label: VGA gain, dB
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0,bias=1
    bb_gain0: vga
    bw0: baseband_filter_bandwidth
    clock_source0: internal
    freq0: carrier_freq
    gain0: amp
    gain_mode0: 'True'
    if_gain0: lna
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: carrier_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0,9,6
    legend: 'False'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
